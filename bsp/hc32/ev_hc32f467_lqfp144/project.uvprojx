# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F467RGTI HDSC
  pack: HDSC.HC32F467.1.0.2
  cpu: IROM1(0x00000000,0x100000) IROM2(0x03000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: __RTTHREAD__, HC32F467, USE_DDL_DRIVER, RT_USING_LIBC, __DEBUG, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC
  c include: .;applications;board;board\ports;board\config;board\config\usb_config;packages\hc32-f4-cmsis-latest\Include;packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f467\Include;packages\hc32-f4-series-latest\hc32f467\inc;..\..\..\include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\net\utest;..\libraries\hc32_drivers;..\platform\tca9539;..\tests
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c xtal32_fcm.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_inputcapture.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_tmr_capture.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group HC32F467-LL
    packages/hc32-f4-series-latest/hc32f467/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_sram.c hc32_ll_utility.c hc32f467_ll_interrupts_share.c hc32_ll_usart.c hc32_ll_tmr0.c hc32_ll_i2c.c hc32_ll_tmr6.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f467/Source/: system_hc32f467.c
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f467/Source/ARM/: startup_hc32f467.s
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_uart_v1.c test_i2c.c test_soft_i2c.c test_gpio.c
