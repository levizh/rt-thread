# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F334KATI HDSC
  pack: HDSC.HC32F334.1.0.0
  cpu: IROM1(0x00000000,0x20000) IROM2(0x03000000,0x1800) IRAM1(0x1FFFC000,0x8000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __DEBUG, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_DDL_DRIVER, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, HC32F334
  c include: ..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\smp_call;..\libraries\hc32_drivers;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\tests;..\..\..\components\libc\posix\io\epoll;board\config;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f334\Include;board;..\..\..\include;.;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;applications;packages\hc32-f4-series-latest\hc32f334\inc;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\ipc;board\ports;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\hc32-f4-cmsis-latest\Include;..\..\..\components\drivers\phy;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFFC000 size 0x8000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: xtal32_fcm.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group HC32F334-LL
    packages/hc32-f4-series-latest/hc32f334/src/: hc32_ll_tmr0.c hc32_ll.c hc32_ll_i2c.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_efm.c hc32_ll_interrupts.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_rmu.c hc32_ll_fcg.c hc32_ll_utility.c hc32_ll_dma.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_pwc.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f334/Source/: system_hc32f334.c
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f334/Source/ARM/: startup_hc32f334.s
  group Tests
    ../tests/: test_soft_i2c.c test_i2c.c test_uart_v1.c test_gpio.c
