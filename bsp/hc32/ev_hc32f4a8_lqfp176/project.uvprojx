# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A8SITB HDSC
  pack: HDSC.HC32F4A8.1.0.0
  cpu: IROM1(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __DEBUG, __RTTHREAD__, RT_USING_ARMLIBC, HC32F4A8, USE_DDL_DRIVER, RT_USING_LIBC
  c include: ..\..\..\components\libc\posix\io\poll;..\libraries\hc32f4a8_ddl\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\libraries\hc32_drivers;..\platform\tca9539;..\libraries\hc32f4a8_ddl\hc32_ll_driver\inc;..\..\..\components\drivers\include;.;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\ipc;applications;..\..\..\components\finsh;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\smp_call;..\libraries\hc32f4a8_ddl\cmsis\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;board\ports;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension;board;..\..\..\include;board\config;board\config\usb_config;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\tests
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c xtal32_fcm.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f4a8_ddl/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a8.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c rt_vsscanf.c kerrno.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/hc32f4a8_ddl/hc32_ll_driver/src/: hc32_ll_fcg.c hc32f4a8_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_gpio.c hc32_ll.c hc32_ll_utility.c hc32_ll_pwc.c hc32_ll_dma.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_aos.c hc32_ll_usart.c hc32_ll_clk.c hc32_ll_tmr0.c hc32_ll_i2c.c
    ../libraries/hc32f4a8_ddl/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a8.c
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_uart_v1.c test_gpio.c test_soft_i2c.c test_i2c.c
