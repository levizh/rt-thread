# IAR project project.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; HC32F4A8; __DEBUG; USE_DDL_DRIVER; __RTTHREAD__; USE_DDL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\components\drivers\smp_call; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\drivers\phy; ..\..\..\include; ..\platform\tca9539; ..\..\..\components\libc\compilers\common\extension; board\config; packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f4a8\Include; board\config\usb_config; packages\hc32-f4-cmsis-latest\Include; packages\hc32-f4-series-latest\hc32f4a8\inc; ..\..\..\components\libc\posix\io\poll; ..\tests; ..\..\..\components\drivers\include; ..\libraries\hc32_drivers; ..\..\..\libcpu\arm\cortex-m4; applications; .; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\libcpu\arm\common; board\ports; board; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\finsh; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F4A8_2M_= 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group Applications
    applications/: xtal32_fcm.c main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c cmd.c msh_parse.c
  group HC32F4A8-LL
    packages/hc32-f4-series-latest/hc32f4a8/src/: hc32_ll_tmr0.c hc32_ll_aos.c hc32_ll.c hc32_ll_clk.c hc32_ll_icg.c hc32_ll_pwc.c hc32_ll_sram.c hc32f4a8_ll_interrupts_share.c hc32_ll_usart.c hc32_ll_i2c.c hc32_ll_interrupts.c hc32_ll_dma.c hc32_ll_fcg.c hc32_ll_efm.c hc32_ll_utility.c hc32_ll_rmu.c hc32_ll_gpio.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kstdio.c kerrno.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f4a8/Source/IAR/: startup_hc32f4a8.s
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f4a8/Source/: system_hc32f4a8.c
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_gpio.c test_i2c.c test_soft_i2c.c test_uart_v1.c
