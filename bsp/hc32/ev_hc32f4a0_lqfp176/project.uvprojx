# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.7
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, HC32F4A0, __RTTHREAD__, __DEBUG
  c include: ..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\include;..\..\..\include;..\libraries\hc32f4a0_ddl\cmsis\Device\HDSC\hc32f4xx\Include;..\libraries\hc32_drivers;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\..\..\components\drivers\include;applications;..\libraries\hc32f4a0_ddl\hc32_ll_driver\inc;board\config;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\ipc;board\ports;board;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;board\config\usb_config;..\libraries\hc32f4a0_ddl\cmsis\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: app_spi.c xtal32_fcm.c app_qspi.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f4a0_ddl/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_irq.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/hc32f4a0_ddl/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_utility.c hc32f4a0_ll_interrupts_share.c hc32_ll_interrupts.c hc32_ll_aos.c hc32_ll_usart.c hc32_ll_pwc.c hc32_ll_tmr0.c hc32_ll_icg.c hc32_ll_rmu.c hc32_ll_fcg.c hc32_ll_sram.c hc32_ll_dma.c
    ../libraries/hc32f4a0_ddl/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
