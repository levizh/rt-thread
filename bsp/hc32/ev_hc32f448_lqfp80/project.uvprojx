# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F448MCTI HDSC
  pack: HDSC.HC32F448.1.0.0
  cpu: IROM1(0x00000000,0x40000) IROM2(0x03000C00,0x400) IRAM1(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, __RTTHREAD__, __DEBUG, HC32F448
  c include: ..\..\..\components\drivers\include;..\libraries\hc32f448_ddl\drivers\hc32_ll_driver\inc;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;board\config;board\ports;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\finsh;board;..\..\..\components\libc\compilers\common\include;..\libraries\hc32f448_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\libcpu\arm\common;..\libraries\hc32f448_ddl\drivers\cmsis\Include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;.;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\stdio;..\..\..\libcpu\arm\cortex-m4;..\libraries\hc32_drivers;..\..\..\include;applications
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x03000C00 size 0x400
  memory RVCT9: RAM 0x1FFF8000 size 0x10000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f448_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f448.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_irq.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/hc32f448_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_fcg.c hc32_ll_interrupts.c hc32_ll_sram.c hc32_ll_pwc.c hc32_ll_aos.c hc32_ll_fcm.c hc32_ll.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_usart.c hc32_ll_rmu.c hc32_ll_tmr0.c hc32_ll_dma.c
    ../libraries/hc32f448_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f448.c
